# Keil uVision project wanlix.uvproj, settings and files
target OS_Wanlix (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wanlix +hex (library)
  c flags: Optim=3
  c include: ..\wanlix;..\srccode;..\lib\CMSIS\CM3\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\src;..\lib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\others\STM3210E-EVAL.sct
  group wanlix
    ../wanlix/: wlx_core_a.asm wlx_core_c.c
  group others
    ../others/: 说明.txt

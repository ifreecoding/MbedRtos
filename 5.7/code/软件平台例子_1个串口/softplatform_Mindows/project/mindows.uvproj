# Keil uVision project mindows.uvproj, settings and files
target RTOS_Mindows (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mindows +hex
  c flags: Optim=3
  c include: ..\mindows;..\srccode;..\lib\CMSIS\CM3\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\src;..\lib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\others\STM3210E-EVAL.sct
  group mindows
    ../mindows/: mds_core_a.asm mds_core_c.c mds_list.c mds_chip.c mds_task.c mds_sem.c mds_queue.c mds_debug.c
  group srccode
    ../srccode/: mds_userroot.c system_stm32f10x.c stm32f10x_it.c bufpool.c device.c uart.c schedule.c msg_rx.c msg_tx.c msgprint.c process.c task.c message.c unoptimize.c
  group others
    ../others/: startup_stm32f10x_hd.s STM3210E-EVAL.sct 说明.txt
  group lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
